# Keil uVision project MockProject.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MockProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group MAIN
    ./: main.c S32K144.h
  group APP_FUNCTION
    ./: APP_FUNCTION.c APP_FUNCTION.h
  group NVIC
    ./: Nvic.c Nvic.h Nvic_Register.h
  group GPIO
    ./: Gpio.c Gpio.h Gpio_Register.h Gpio_Isr.c
  group PORT
    ./: Port.c Port.h Port_Register.h
  group CLOCK
    ./: Clock.c Clock.h Clock_Register.h
  group SOFTTIMER
    ./: Softtimer.c Softtimer.h Systick_Register.h
  group LPIT
    ./: Lpit.c Lpit.h Lpit_Register.h
  group LPUART
    ./: Lpuart.c Lpuart.h Lpuart_Register.h
  group LPSPI
    ./: Lpspi.c Lpspi.h Lpspi_Register.h
  group STRING
    ./: String.c String.h
  group LED_MAX7219
    ./: LED_MAX7219.c LED_MAX7219.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
